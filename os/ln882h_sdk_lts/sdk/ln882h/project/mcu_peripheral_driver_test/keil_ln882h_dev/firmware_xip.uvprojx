# Keil uVision project firmware_xip.uvprojx, settings and files
target mcu_xip (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: firmware_xip +hex
  BeforeMake: python    ..\..\..\tools\python_scripts\sdk_env_check.py
  BeforeMake: python3 ..\..\..\tools\python_scripts\before_build_keil.py  -p  ..\cfg\flash_partition_cfg.json -o  ..\cfg\flash_partition_table.h
  AfterMake: python3  ..\..\..\tools\python_scripts\after_build_keil.py  -k   #P   -o flashimage.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HAL_ASSERT_EN,LN882H
  c include: ..\app;..\bsp;..\cfg;..\startup;..\..\..\mcu\CMSIS_5.3.0;..\..\..\mcu\driver_ln882h\hal;..\..\..\mcu\driver_ln882h\reg;..\..\..\mcu\ln882h;..\..\..\mcu\driver_ln882h;..\..\..\components\utils;..\..\..\components;..\..\..\components\serial;..\..\..\components\utils\debug;..\..\..\components\kernel
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\peripheral_test.sct
  group cpu
    ../startup/: startup_ln882h.S
    ../../../mcu/ln882h/: system_ln882h.c
  group main
    ../app/: main.c
    ../bsp/: ln_show_reg.c
  group bsp
    ../bsp/: serial_hw.c ln_test_common.c ln_uart_test.c ln_spi_master_test.c ln_spi_slave_test.c ln_i2c_test.c ln_mpu9250_test.c ln_oled_test.c ln_timer_test.c ln_rtc_test.c ln_adv_timer_test.c ln_wdt_test.c ln_i2s_test.c ln_ws2811_test.c ln_dma_test.c ln_gpio_test.c ln_ext_test.c ln_flash_test.c ln_sdio_test.c ln_aes_test.c ln_ds18b20_test.c ln_clk_test.c ln_trng_test.c ln_adc_test.c ln_spi_lcd_test.c
  group drv_hal
    ../../../mcu/driver_ln882h/hal/: hal_adc.c hal_aes.c hal_cache.c hal_common.c hal_dma.c hal_ext.c hal_flash.c hal_gpio.c hal_i2s.c hal_it.c hal_i2c.c hal_qspi.c hal_rtc.c hal_spi.c hal_timer.c hal_trng.c hal_uart.c hal_wdt.c hal_ws2811.c hal_misc.c hal_clock.c hal_adv_timer.c hal_sdio_device.c hal_efuse.c
  group util
    ../../../components/utils/fifo/: fifobuf.c
  group debug
    ../../../components/utils/debug/: ln_assert.c log.c
    ../../../components/utils/: wrap_stdio.c
  group serial
    ../../../components/serial/: serial.c
